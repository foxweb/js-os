// xcl-file for assembler-only projects
-Fraw-binary
-cz80
-Z(CODE)CODE=0000-37FF
-Z(CONST)FONT8=3800-3FFF
--image_input=jms-font.fnt,font8,FONT8,1
-o js-os.bin
-l js-os.map
-xmisn
